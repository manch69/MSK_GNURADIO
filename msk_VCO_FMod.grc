options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: Ar
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Ruido
    orient: Qt.Horizontal
    start: '0'
    step: (4.)/50.
    stop: '4.'
    value: '0.'
  states: {}
- name: Kf
  id: variable
  parameters:
    value: '25'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: 12e3
  states: {}
- name: Sensitivity
  id: variable
  parameters:
    value: (math.pi/2)/Sps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Tupdate
  id: variable
  parameters:
    value: 1./Rb
  states: {}
- name: nTaps
  id: variable
  parameters:
    value: Sps*4
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rb*Sps
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: Sensitivity
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: Ar
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: b_PSD_0
  id: b_PSD
  parameters:
    Ensayos: '1000000'
    N: '1024'
    Titulo: '''espectro'''
    Ymax: '5e-6'
    samp_rate: samp_rate
  states: {}
- name: b_PSD_c_0
  id: b_PSD_c
  parameters:
    Ensayos: '1000000'
    Fc: '0'
    N: '1024'
    Ymax: '6e-6'
    samp_rate_audio: samp_rate
  states: {}
- name: b_binary_bipolar_source_f_0
  id: b_binary_bipolar_source_f
  parameters:
    Am: '1.'
    Spb: '1'
  states: {}
- name: b_upconverter_cf_0
  id: b_upconverter_cf
  parameters:
    Fc: '16000'
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Sensitivity
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: (-1,1)
  states: {}
- name: e_VCO_fase_fc_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  \n    \"\"\"Done by Homero Ortega Boada. Es un VCO dos entradas: \nin0 para manipular la fase, in1 para manipular la \nmagnitud. En el fondo es el equivalente a un generador\nde una senal exponencial compleja. Sobre la configuracion:\ncada valor de la senal en in0 es interpretada como la fase\ndeseada en radianes. cada valor de in0, es la magnitud deseada\"\"\"\n\n    def __init__(self): \n        gr.sync_block.__init__(self,\n            name='e_VCO_fase_fc',\n            in_sig=[np.float32, np.float32],\n            out_sig=[np.complex64]\n        )\n    def work(self, input_items, output_items):\n        in0=input_items[0]\n        in1=input_items[1]\n        out0=output_items[0]\n        out0[:] = in1*np.exp(1.j*in0)\n        return len(out0)\n"
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Hecho por Homoero Ortega. Es un acumulador puro, va acumulando cada muestra entrante mientras entrega lo que lleva acumulado hasta el momento. Puede convertirse en un integrador si la salida se divide en la frecuencia de muestreo de la senal"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='e_Accum_ff',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.memory=0.

          def work(self, input_items, output_items):
              """El acumulador"""
              in0=input_items[0]
              out0=output_items[0]
              L=len(in0)
              out0[:]=(self.memory+np.cumsum(in0))
              self.memory=out0[L-1]
              return len(out0)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import wform
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: wform.rrcos(Sps,nTaps,0.5)
    type: fff
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 4,0,1,1
    label1: '''.'''
    name: ''
    nconnections: '2'
    size: '4000'
    type: complex
    update_time: Tupdate
    width1: '4'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,1,1,2
    label1: Mensaje
    label2: MSK parte real
    label3: MSK parte Imaginaria
    label4: MSK_FM Real
    label5: MSK_FM Imag
    label6: PasaBanda
    name: '"compararacion entre mensaje y EC"'
    nconnections: '6'
    size: '1024'
    srate: (samp_rate)
    type: float
    update_time: Tupdate
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    width6: '2'
    ylabel: Amplitud
    ymax: '1.5'
    ymin: '-1.5'
    yunit: volts
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: P1.2
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: chunk
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: P1.2
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: chunk
  states: {}
- name: vs
  id: virtual_sink
  parameters:
    stream_id: P1
  states: {}
- name: vs_0
  id: virtual_sink
  parameters:
    stream_id: P2
  states: {}
- name: vso
  id: virtual_source
  parameters:
    stream_id: P1
  states: {}
- name: vso_0
  id: virtual_source
  parameters:
    stream_id: P2
  states: {}

connections:
- [analog_const_source_x_0_0, '0', e_VCO_fase_fc_0, '1']
- [analog_frequency_modulator_fc_0, '0', blocks_throttle_0_0, '0']
- [analog_noise_source_x_1, '0', blocks_add_xx_1, '1']
- [b_binary_bipolar_source_f_0, '0', blocks_float_to_char_0, '0']
- [b_binary_bipolar_source_f_0, '0', vs_0, '0']
- [b_upconverter_cf_0, '0', b_PSD_0, '0']
- [b_upconverter_cf_0, '0', qtgui_time_sink_x_0_0_0_0_0, '5']
- [blocks_add_xx_1, '0', blocks_throttle_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_0_0_0_0, '1']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0_0_0_0_0, '2']
- [blocks_complex_to_float_1, '0', qtgui_time_sink_x_0_0_0_0_0, '3']
- [blocks_complex_to_float_1, '1', qtgui_time_sink_x_0_0_0_0_0, '4']
- [blocks_float_to_char_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_multiply_const_vxx_0_0_0_1_0_0, '0', e_VCO_fase_fc_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_1, '0']
- [blocks_throttle_0, '0', vs, '0']
- [blocks_throttle_0_0, '0', virtual_sink_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', virtual_sink_1, '0']
- [e_VCO_fase_fc_0, '0', blocks_add_xx_1, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_0_0_0_1_0_0, '0']
- [interp_fir_filter_xxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [interp_fir_filter_xxx_0, '0', epy_block_0, '0']
- [virtual_source_0, '0', b_PSD_c_0, '0']
- [virtual_source_0, '0', b_upconverter_cf_0, '0']
- [virtual_source_0, '0', blocks_complex_to_float_1, '0']
- [virtual_source_0, '0', qtgui_const_sink_x_0, '1']
- [virtual_source_1, '0', interp_fir_filter_xxx_0, '0']
- [vso, '0', blocks_complex_to_float_0, '0']
- [vso, '0', qtgui_const_sink_x_0, '0']
- [vso_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']

metadata:
  file_format: 1
